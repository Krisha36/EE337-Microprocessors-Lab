ORG 0H
LJMP MAIN
ORG 100H
MAIN:
CALL QUANT
HERE: SJMP HERE
ORG 130H
// *****************
QUANT:
// ADD YOUR CODE HERE

MOV R0 , #77H
MOV R1 , #67H
MOV R2 , #8H

COMPARE:
MOV B , @R1
MOV A , #0AH
SUBB A , B
JZ STORE15
JNC STORE5
CLR C
MOV A , #14H
SUBB A , B
JZ STORE25
JNC STORE15
CLR C
MOV A , #1EH
SUBB A , B
JZ STORE35
JNC STORE25
JC STORE35
RET

STORE5:
MOV @R0 , #05H
DEC R1
DEC R0
DJNZ R2 , COMPARE
RET

STORE15:
MOV @R0 , #0FH
DEC R1
DEC R0
DJNZ R2 , COMPARE
RET

STORE25:
MOV @R0 , #19H
DEC R1
DEC R0
DJNZ R2 , COMPARE
RET
	
STORE35:
MOV @R0 , #23H
DEC R1
DEC R0
DJNZ R2 , COMPARE
RET



END