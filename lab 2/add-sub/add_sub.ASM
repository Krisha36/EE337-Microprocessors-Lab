// -- DO NOT CHANGE ANYTHING UNTIL THE **** LINE--//
ORG 0H
LJMP MAIN
ORG 100H
MAIN:
MOV R1, #61H
ACALL MODADD
ACALL MODSUB
HERE: SJMP HERE
ORG 130H
// *****************
MODADD:
// ADD YOUR CODE HERE
MOV A, 70H
MOV B, R1
DIV AB
MOV R3, B
MOV A, 71H
MOV B, R1
DIV AB
MOV A, B
ADD A, R3
MOV B, R1
DIV AB
MOV 72H, B
RET

MODSUB:
// ADD YOUR CODE HERE
MOV A, 70H
MOV B, R1
DIV AB
MOV R2, B
MOV A, 71H
MOV B, R1
DIV AB
MOV A, B
XCH A, R2
SUBB A, R2
MOV	73H, A
JC BORROWCASE
RET

BORROWCASE:
ADD A, R1
MOV 73H, A
RET
END