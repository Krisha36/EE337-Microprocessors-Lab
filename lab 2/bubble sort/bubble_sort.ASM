// -- DO NOT CHANGE ANYTHING UNTIL THE **** LINE--//
ORG 0H
LJMP MAIN
ORG 100H
MAIN:
ACALL SORT
HERE: SJMP HERE
ORG 130H
// *****************

SORT:
// ADD YOUR CODE HERE
MOV R0, #7H

OUTERLOOP:
MOV 30H, R0
MOV R1, #60H
INNERLOOP: 
MOV B, @R1
INC R1
MOV A, @R1
SUBB A, B
JNC SKIPifasc
CPL C
MOV A, B
MOV B, @R1
DEC R1
MOV @R1, B
INC R1
MOV @R1, A

SKIPifasc:
DJNZ 30H, INNERLOOP
DJNZ R0, OUTERLOOP

MOV 70H, 60H
MOV 71H, 61H
MOV 72H, 62H
MOV 73H, 63H
MOV 74H, 64H
MOV 75H, 65H
MOV 76H, 66H
MOV 77H, 67H


RET
END